## boards/shields/lagom/kconfig.shield
```kconfig
# Copyright (c) 2020 The ZMK Contributors
# SPDX-License-Identifier: MIT

config SHIELD_lagom
    def_bool $(shields_list_contains,lagom)
```
